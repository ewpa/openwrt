## target/linux/cv18x0/image/Config.in
```kconfig
config CV18X0_SD_BOOT_PARTSIZE
	int "Boot (SD Card) filesystem partition size (in MB)"
	depends on TARGET_cv18x0
	default 32
```
